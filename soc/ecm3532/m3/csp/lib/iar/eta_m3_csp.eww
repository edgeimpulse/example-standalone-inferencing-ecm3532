<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\eta_m3_csp.ewp</path>
    </project>
    <batchBuild />
</workspace>
