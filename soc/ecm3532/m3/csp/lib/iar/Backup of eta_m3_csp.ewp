# IAR project Backup of eta_m3_csp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ECM3532 EtaCompute ECM3532
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\reg\inc; ..\..\..\..\common\csp\inc; ..\..\..\..\..\common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eta_m3_csp.srec
  ILINK.IlinkOutputFile: eta_m3_csp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    ../../src/: eta_csp.c eta_csp_adc.c eta_csp_buck.c eta_csp_dsp.c eta_csp_flash.c eta_csp_gpio.c eta_csp_hfo.c eta_csp_i2c.c eta_csp_i2s.c eta_csp_io.c eta_csp_isr.c eta_csp_lfo.c eta_csp_m3.c eta_csp_nvic.c eta_csp_pdm.c eta_csp_pwm.c eta_csp_pwr.c eta_csp_rtc.c eta_csp_socctrl.c eta_csp_spi.c eta_csp_sys_clock.c eta_csp_timer.c eta_csp_tsense.c eta_csp_uart.c eta_csp_vhfo.c
